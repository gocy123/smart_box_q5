# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL; USE_STM32100B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  ICCARM.CCOptLevel: 3
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCOptLevel: 3
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\OS\BSP; ..\..\OS\uC-CPU\ARM-Cortex-M3\IAR; ..\..\OS\uC-CPU; ..\..\OS\uC-LIB; ..\..\OS\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\OS\uCOS-III\Source; ..\..\OS\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Utility; ..\..\network_layer\nwl_uart1; ..; ..\..\network_layer\nwl_uart2; ..\..\App\user_debug; ..\..\App\dev_manage; ..\..\App\modem\sim800; ..\..\App\protocol_communication\protocol_jt808; ..\..\App\rtc; ..\..\App\gps; ..\..\network_layer\nwl_uart3; ..\..\App\modem\quecelMC20; ..\..\App\rf; ..\..\App\internal_flash
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkIcfFile: Project.icf
configuration STM32100E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD_VL; USE_STM32100E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL
  ICCARM.CCOptLevel: 3
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xG ST STM32F103xG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group App/device_manage
    ../../App/dev_manage/: DeviceManage.c
  group App/gps
    ../../App/gps/: user_gps_app.c
  group App/internal_flash
    ../../App/internal_flash/: user_internal_flash.c
  group App/modem/sim800
    ../../App/modem/sim800/: modem_sim800_app.c modem_sim800_AT_pro.c
  group App/rf
    ../../App/rf/: Encoding.o Encoding_v8.c user_rf_app.c
  group App/rtc
    ../../App/rtc/: user_rtc_app.c
  group App/tel_protocol_manage
    ../../App/protocol_communication/protocol_jt808/: jt808_protocol_rx.c jt808_protocol_tx.c jt808_pt_misc.c jt808_telecom_prot_manage.c
  group App/user_debug
    ../../App/user_debug/: user_debug_app.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group EWARMv5
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group NWL/nwl_uart1
    ../../network_layer/nwl_uart1/: uart1_network_layer.c
  group NWL/nwl_uart2
    ../../network_layer/nwl_uart2/: uart2_network_layer.c
  group NWL/nwl_uart3
    ../../network_layer/nwl_uart3/: uart3_network_layer.c
  group OS/uC-BSP
    ../../OS/BSP/: bsp.c os_app_hooks.c os_cfg_app.c
  group OS/uc-CPU
    ../../OS/uC-CPU/: cpu_core.c
  group OS/uc-CPU/cm3
    ../../OS/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group OS/uC-Lib
    ../../OS/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group OS/uC-Lib/ports
    ../../OS/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group OS/uCOS-III/ports
    ../../OS/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group OS/uCOS-III/source
    ../../OS/uCOS-III/Source/: os.h os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: main.c stm32f10x_it.c
  group Utility
    ../../Utility/: Common.c ringbuffer.c
